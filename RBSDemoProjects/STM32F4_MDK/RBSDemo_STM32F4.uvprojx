# Keil uVision project RBSDemo_STM32F4.uvprojx, settings and files
target RBSDemo_Normal (ARM-ADS)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RBSDemo_STM32F4 +hex
  c flags: Optim=1
  c define: STM32F40_41xxx,RBS_CFG_APP_MODEL=RBS_APP_NONE
  c include: .\Demo;..\..\RBSSource\Config;..\..\RBSSource\Base\Protothreads;..\..\RBSSource;.\CMSIS\CMSIS_RTX;.\CMSIS\Core;.\CMSIS\Device
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Demo
    ./Demo/: main.c retarget.c
    ../../RBSSource/: RainbowBS.h
  group RBS_Config
    ../../RBSSource/Config/: RainbowBSConf.h
  group RBS_Base
    ../../RBSSource/Base/: Convert.c Debug.c DMM.c MemOP.c System.c
    ../../RBSSource/Base/Process/: etimer.c process.c
    ../../RBSSource/Base/Protothreads/: lc.h lc-switch.h pt.h pt-sem.h
  group RBS_Port
    ../../RBSSource/Port/: Port.c Port.h
  group CMSIS_RTX
    ./CMSIS/CMSIS_RTX/: cmsis_os.h RTX_Conf_CM.c RTX_CM_lib.h RTX_CM4.lib
  group CMSIS_Core
    ./CMSIS/Core/: core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h
  group CMSIS_Device
    ./CMSIS/Device/: startup_stm32f40_41xxx.s stm32f4xx.h stm32f4xx_it.c stm32f4xx_it.h system_stm32f4xx.c system_stm32f4xx.h
target RBSDemo_PTP (ARM-ADS)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.3.0
  cpu: as above
  output: RBSDemo_STM32F4 +hex
  c flags: Optim=1
  c define: STM32F40_41xxx,RBS_CFG_APP_MODEL=RBS_APP_PTP
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
target RBSDemo_OS (ARM-ADS)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.3.0
  cpu: as above
  output: RBSDemo_STM32F4 +hex
  c flags: Optim=1
  c define: STM32F40_41xxx,RBS_CFG_APP_MODEL=RBS_APP_OS
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
